OBMC_IMAGE_EXTRA_INSTALL:append:romulus = " hello-openbmc"
OBMC_IMAGE_EXTRA_INSTALL:append:romulus = " mock-sensor"
